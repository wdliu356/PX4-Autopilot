## src/drivers/trisonica_mini/Kconfig
```kconfig
menuconfig DRIVERS_TRISONICA_MINI
	bool "trisonica_mini"
	default n
	---help---
		Enable support for trisonica_mini
```
